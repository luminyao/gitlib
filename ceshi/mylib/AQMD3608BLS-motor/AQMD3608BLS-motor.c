/*电机串口配置*/
#include "AQMD3608BLS-motor.h"

uint16_t Buff[128];			//±£´æ¸÷¸ö¼Ä´æÆ÷µÄÖµ
uint8_t adr;						//±£´æ´Ó»úµØÖ·

static unsigned char auchCRCHi[] = 
{
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81,
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
	0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
	0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
	0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
	0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
	0x40
};

//CRCµÍ×Ö½Ú
static char auchCRCLo[] = 
{
	0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4,
	0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
	0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD,
	0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
	0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7,
	0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
	0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE,
	0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
	0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2,
	0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
	0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB,
	0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
	0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91,
	0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
	0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88,
	0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
	0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80,
	0x40
};

void usart3_init( u32 bound )
{
	NVIC_InitTypeDef	NVIC_InitStructure;
	GPIO_InitTypeDef	GPIO_InitStructure;
	USART_InitTypeDef	USART_InitStructure;

	RCC_APB2PeriphClockCmd( RCC_APB2Periph_GPIOB, ENABLE );                                 /* Ê¹ÄÜGPIOBÊ±ÖÓ */
	RCC_APB1PeriphClockCmd( RCC_APB1Periph_USART3, ENABLE );                                /* Ê¹ÄÜUSART3Ê±ÖÓ */

	USART_DeInit( USART3 );                                                                 /*¸´Î»´®¿Ú3 */

	/* USART3_TX   PB10 */
	GPIO_InitStructure.GPIO_Pin	= GPIO_Pin_10;																							/* PB10 */
	GPIO_InitStructure.GPIO_Speed	= GPIO_Speed_50MHz;
	GPIO_InitStructure.GPIO_Mode	= GPIO_Mode_AF_PP;                                    		/*¸´ÓÃÍÆÍìÊä³ö */
	GPIO_Init( GPIOB, &GPIO_InitStructure );                                                /* ³õÊ¼»¯PB10 */

	/* USART3_RX	  PB11 */
	GPIO_InitStructure.GPIO_Pin	= GPIO_Pin_11;
	GPIO_InitStructure.GPIO_Mode = GPIO_Mode_IN_FLOATING;                                		/* ¸¡¿ÕÊäÈë */
	GPIO_Init( GPIOB, &GPIO_InitStructure );                                                /* ³õÊ¼»¯PB11 */

	USART_InitStructure.USART_BaudRate = bound;																							/* ²¨ÌØÂÊ */
	USART_InitStructure.USART_WordLength = USART_WordLength_8b;                 					  /* ×Ö³¤Îª8Î»Êý¾Ý¸ñÊ½ */
	USART_InitStructure.USART_StopBits = USART_StopBits_2;                    					  	/* Á½¸öÍ£Ö¹Î» */
	USART_InitStructure.USART_Parity = USART_Parity_No;                     							  /* ÎÞÆæÅ¼Ð£ÑéÎ» */
	USART_InitStructure.USART_HardwareFlowControl	= USART_HardwareFlowControl_None;         /* ÎÞÓ²¼þÊý¾ÝÁ÷¿ØÖÆ */
	USART_InitStructure.USART_Mode = USART_Mode_Rx | USART_Mode_Tx;                         /* ÊÕ·¢Ä£Ê½ */

	USART_Init( USART3, &USART_InitStructure );                                             /* ³õÊ¼»¯´®¿Ú3 */

	NVIC_InitStructure.NVIC_IRQChannel = USART3_IRQn;
	NVIC_InitStructure.NVIC_IRQChannelPreemptionPriority	= 1;                              /* ÇÀÕ¼ÓÅÏÈ¼¶1 */
	NVIC_InitStructure.NVIC_IRQChannelSubPriority = 1;                                 			/* ×ÓÓÅÏÈ¼¶1 */
	NVIC_InitStructure.NVIC_IRQChannelCmd = ENABLE;																					/* IRQÍ¨µÀÊ¹ÄÜ */
	NVIC_Init( &NVIC_InitStructure );                                                       /* ¸ù¾ÝÖ¸¶¨µÄ²ÎÊý³õÊ¼»¯VIC¼Ä´æÆ÷ */

	USART_ITConfig( USART3, USART_IT_IDLE, ENABLE );            		 												/* ½ÓÊÕ¿ÕÏÐÖÐ¶Ï */
	
	USART_Cmd( USART3, ENABLE );																														

	USART_DMACmd( USART3, USART_DMAReq_Rx, ENABLE );																				

	MYDMA_Config( DMA1_Channel3, (u32) & USART3->DR, (u32) USART3_RX_BUF, USART3_REC_LEN );	
}

void USART3_IRQHandler( void )                                   		/* ´®¿Ú2ÖÐ¶Ï·þÎñ³ÌÐò */
{
	u8 temp;

	if ( USART_GetITStatus( USART3, USART_IT_IDLE ) != RESET )				/* ½ÓÊÕ¿ÕÏÐÖÐ¶Ï */
	{
		if( (USART3_RX_STA & 0x8000) == 0 )
		{
			DMA_Cmd( DMA1_Channel3, DISABLE );

			temp = USART3_REC_LEN - DMA_GetCurrDataCounter( DMA1_Channel3 );
			USART3_RX_STA	= temp | 0x8000;

			DMA_SetCurrDataCounter( DMA1_Channel3, USART3_REC_LEN );
			DMA_Cmd( DMA1_Channel3, ENABLE );

			temp	= USART3->SR;
			temp	= USART3->DR;			/*	ÕâÁ½¾äÓÃÓÚÇå³ý±êÖ¾Î»£¬¶øUSART_ClearITPendingBit(USART3, USART_IT_IDLE);Ã»ÓÃ */
		}
	}
}

void uart3_SendByte( u8 data )
{
	while ( USART_GetFlagStatus( USART3, USART_FLAG_TC ) != SET );
	USART_SendData( USART3, data );
}

void uart3_SendString( u8 *str , u8 length )
{
	while(length--)
	{
		uart3_SendByte( *str++ );
	}
}

void Modbus_Send(uint8_t *Message , uint16_t Lenth)
{
	uint8_t uchCRCHi = 0xFF; 										/* CRC µÄ¸ß×Ö½Ú³õÊ¼»¯*/
	uint8_t uchCRCLo = 0xFF; 										/* CRC µÄµÍ×Ö½Ú³õÊ¼»¯*/
	uint16_t uIndex ; 													/* CRC ²éÑ¯±íË÷Òý*/
	uint8_t *Message_backup=Message;
	uint16_t Lenth_backup=Lenth;
	
	uint8_t *p,l;

	while (Lenth--) 														/* Íê³ÉÕû¸ö±¨ÎÄ»º³åÇø*/
	{
		uIndex = uchCRCLo ^ *Message++;						/* ¼ÆËãCRC */
		uchCRCLo = uchCRCHi ^ auchCRCHi[uIndex];
		uchCRCHi = auchCRCLo[uIndex];
	}
	
	*(Message_backup+Lenth_backup)=uchCRCLo;
	*(Message_backup+Lenth_backup+1)=uchCRCHi;
	
	p = Message_backup;
	l = Lenth_backup + 2;
	
	uart3_SendString(p,l);
}


uint16_t CRC16(uint8_t *puchMsg , uint16_t usDataLen) 
{
	uint8_t uchCRCHi = 0xFF; 
	uint8_t uchCRCLo = 0xFF; 
	uint16_t uIndex ; 
	while (usDataLen--)
	{
		uIndex = uchCRCLo ^ *puchMsg++;
		uchCRCLo = uchCRCHi ^ auchCRCHi[uIndex];
		uchCRCHi = auchCRCLo[uIndex];
	}
	return (uchCRCHi << 8 | uchCRCLo);
}

uint8_t	Modbus_Check(uint8_t *p ,uint16_t l)
{
	uint16_t num;														
	uint8_t i;
	uint8_t res=0x00;
	
	adr = *p;
	
	if( CRC16(p,l-2) != (((*(p+l-1))<<8) | (*(p+l-2))) )
	{
		res=0x00;																//Ð£Ñé³ö´í
		return res;
	}
	
	res=*(p+1);
	
	switch(res)
	{
		case 0x03:															//¶Á¼Ä´æÆ÷³É¹¦
		{
			num = p[2]/2;													//¼Ä´æÆ÷Îª16Î»
			p+=3;
			
			for( i=0 ; i<num ; i++ )
			{
				Buff[i] = *p<<8 | *(p+1);
				p+=2;
			}
			break;
		}
		
		case 0x06:															//Ð´µ¥¸ö¼Ä´æÆ÷³É¹¦
		{
			break;
		}
		
		case 0x10:															//Ð´¶à¸ö¼Ä´æÆ÷³É¹¦
		{
			break;
		}
		
		case 0x83:															//¶Á¼Ä´æÆ÷³ö´í
		{
			break;
		}
		
		case 0x86:															//Ð´µ¥¸ö¼Ä´æÆ÷³ö´í
		{
			break;
		}
		
		case 0x90:															//Ð´¶à¸ö¼Ä´æÆ÷³ö´í
		{
			break;
		}
		
		default:			
		{
			break;
		}
	}
	
	return res;
}



uint8_t Modbus_WriteSgl(uint8_t Slave, uint16_t Adr, uint16_t Data, uint8_t Re, uint8_t Retry)
{
	uint8_t txt[8],*p,len,res=0x00;	

	txt[0]=Slave;
	txt[1]=0x06;
	txt[3]=(uint8_t)Adr;
	txt[2]=(uint8_t)(Adr>>8);
	txt[5]=(uint8_t)Data;
	txt[4]=(uint8_t)(Data>>8);
	
	while(Retry--)
	{
		USART3_RX_STA = 0;
		Modbus_Send(txt,6);
		
		if(Re)
		{
			uint8_t n=30;
			while(n--)
			{
				delay_us(100);
				
				if(USART3_RX_STA&0x8000)
				{
					p=USART3_RX_BUF;
					len=USART3_RX_STA&0x3fff;
					res=Modbus_Check(p,len);
					return res;
				}
			}
		}
	}
	return 0;
}





